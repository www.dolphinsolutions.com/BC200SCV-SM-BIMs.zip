Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-06-29T23:21:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Jun 29 23:21:00 2024 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\c803199d-5cca-4ee9-ae6b-7d2c8a29a843\bc6ef886-9cb5-414e-ace0-1697a1978465\ifc * Database version: 5507 * Database creation date: Sat Jun 29 23:20:58 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Jun 29 23:20:58 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Jun 29 23:20:58 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: BC200SCV-SM, BC200SCV-SM:BC200SCV-SM:346579
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 100 mm; Length: 551 mm; Width: 889 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_06:Baby Changing Units; CodePerformance: n/a; Color: Brushed Satin; Constituents: n/a; Description: Baby Changing Units; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: www.dolphinsolutions.co.uk; Material: StainlessSteel; ModelNumber: BC200SCV-SM; ModelReference: DolphinSolutionsLimited_BabyChangingUnit_Vertical_SurfaceMounted; Name: BabyChangingUnits_BC200SCV-SM_DolphinSolutionsLimited; NBSDescription: BabyChangingUnits; NBSReference: N13/488; NBSTypeID: n/a; NominalDepth: 100; NominalLength: 889; NominalWidth: 551; OmniClassCode: 23.40.20.21.37; OmniClassDescription: DiaperChangingUnits; ProductInformation: https://www.dolphinsolutions.co.uk/product/vertical-stainless-steel-clad-baby-changing-table/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 889x551x100; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC200SCV-SM; Uniclass2015Code: Pr_40_20_76_06; Uniclass2015Title: BabyChangingUnits; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Specialty Equipment; Family Name: BC200SCV-SM
Type - Pset_BuildingElementProxyCommon - Reference: BC200SCV-SM:BC200SCV-SM
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_BabyChangingUnit_Vertical_SurfaceMounted; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_PrecastConcreteElementGeneral - SerialNumber: n/a
Type - Pset_ProductRequirements - Name: BabyChangingUnits_BC200SCV-SM_DolphinSolutionsLimited; Category: Pr_40_20_76_06:Baby Changing Units
Type - Pset_QuantityTakeOff - Reference: BC200SCV-SM:BC200SCV-SM
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.903487 m2; Volume: 0.0326194 m3
Other - Family: BC200SCV-SM: BC200SCV-SM; Family and Type: BC200SCV-SM: BC200SCV-SM; Type: BC200SCV-SM: BC200SCV-SM; Type Id: BC200SCV-SM: BC200SCV-SM
Phasing - Phase Created: New Construction
